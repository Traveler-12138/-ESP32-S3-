## sdkconfig.defaults
```kconfig
# sdkconfig.defaults
# 抑制旧版 I2S API 弃用警告（INMP441 在新 API 下数据错位，需用旧版 API）
CONFIG_I2S_SUPPRESS_DEPRECATE_WARN=y
CONFIG_I2S_SKIP_LEGACY_CONFLICT_CHECK=y
```
